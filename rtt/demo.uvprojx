# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\demo1;.\System\delay;.\System\sys;.\System\delay;.\Hardware\LED;.\System\usart;.\Hardware\CD100M;.\Hardware\HX711;.\Hardware\BC28;.\USER\APP;.\USER\drv_bc28;.\USER\User_defined;.\USER\drv_hx711;.\Hardware\zigbee_a72;.\Hardware\lw_oopc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
    ./USER/APP/: app.c
    ./USER/drv_bc28/: drv_bc28.c
    ./USER/User_defined/: user_defined.c
    ./USER/drv_hx711/: drv_hx711.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/CD100M/: cd100m.c
    ./Hardware/HX711/: hx711.c
    ./Hardware/BC28/: bc28.c
    ./Hardware/zigbee_a72/: zigbee_a72.c
    ./Hardware/lw_oopc/: lw_oopc.c
  group System
    ./System/usart/: usart.c
    ./System/sys/: sys.c
    ./System/delay/: delay.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, RTOS:device 3.1.5, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
